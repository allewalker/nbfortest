# Keil uVision project bootloader.uvprojx, settings and files
target base (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\..\Inc;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Platform
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../../Hal/: bootloader.c dma.c nvram.c usart.c setting.c
    ../../App/: debug.c api.c
  group lib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_gpio.c misc.c
  group platform
    ../../Platform/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
